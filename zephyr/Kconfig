## zephyr/Kconfig
```kconfig
config SOEM
	bool "Simple Open EtherCAT Master Library (SOEM)"
	default y
	select POSIX_TIMERS
	help
	  wip
```
